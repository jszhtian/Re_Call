// hbSceneDec.cpp : 定义控制台应用程序的入口点。
//

#include "stdafx.h"

#include <windows.h>
#include <stdio.h>
unsigned char pck_xor_table[256] = {
0x70, 0xF8, 0xA6, 0xB0, 0xA1, 0xA5, 0x28, 0x4F, 0xB5, 0x2F, 0x48, 0xFA, 0xE1, 0xE9, 0x4B, 0xDE,
0xB7, 0x4F, 0x62, 0x95, 0x8B, 0xE0, 0x03, 0x80, 0xE7, 0xCF, 0x0F, 0x6B, 0x92, 0x01, 0xEB, 0xF8,
0xA2, 0x88, 0xCE, 0x63, 0x04, 0x38, 0xD2, 0x6D, 0x8C, 0xD2, 0x88, 0x76, 0xA7, 0x92, 0x71, 0x8F,
0x4E, 0xB6, 0x8D, 0x01, 0x79, 0x88, 0x83, 0x0A, 0xF9, 0xE9, 0x2C, 0xDB, 0x67, 0xDB, 0x91, 0x14,
0xD5, 0x9A, 0x4E, 0x79, 0x17, 0x23, 0x08, 0x96, 0x0E, 0x1D, 0x15, 0xF9, 0xA5, 0xA0, 0x6F, 0x58,
0x17, 0xC8, 0xA9, 0x46, 0xDA, 0x22, 0xFF, 0xFD, 0x87, 0x12, 0x42, 0xFB, 0xA9, 0xB8, 0x67, 0x6C,
0x91, 0x67, 0x64, 0xF9, 0xD1, 0x1E, 0xE4, 0x50, 0x64, 0x6F, 0xF2, 0x0B, 0xDE, 0x40, 0xE7, 0x47,
0xF1, 0x03, 0xCC, 0x2A, 0xAD, 0x7F, 0x34, 0x21, 0xA0, 0x64, 0x26, 0x98, 0x6C, 0xED, 0x69, 0xF4,
0xB5, 0x23, 0x08, 0x6E, 0x7D, 0x92, 0xF6, 0xEB, 0x93, 0xF0, 0x7A, 0x89, 0x5E, 0xF9, 0xF8, 0x7A,
0xAF, 0xE8, 0xA9, 0x48, 0xC2, 0xAC, 0x11, 0x6B, 0x2B, 0x33, 0xA7, 0x40, 0x0D, 0xDC, 0x7D, 0xA7,
0x5B, 0xCF, 0xC8, 0x31, 0xD1, 0x77, 0x52, 0x8D, 0x82, 0xAC, 0x41, 0xB8, 0x73, 0xA5, 0x4F, 0x26,
0x7C, 0x0F, 0x39, 0xDA, 0x5B, 0x37, 0x4A, 0xDE, 0xA4, 0x49, 0x0B, 0x7C, 0x17, 0xA3, 0x43, 0xAE,
0x77, 0x06, 0x64, 0x73, 0xC0, 0x43, 0xA3, 0x18, 0x5A, 0x0F, 0x9F, 0x02, 0x4C, 0x7E, 0x8B, 0x01,
0x9F, 0x2D, 0xAE, 0x72, 0x54, 0x13, 0xFF, 0x96, 0xAE, 0x0B, 0x34, 0x58, 0xCF, 0xE3, 0x00, 0x78,
0xBE, 0xE3, 0xF5, 0x61, 0xE4, 0x87, 0x7C, 0xFC, 0x80, 0xAF, 0xC4, 0x8D, 0x46, 0x3A, 0x5D, 0xD0,
0x36, 0xBC, 0xE5, 0x60, 0x77, 0x68, 0x08, 0x4F, 0xBB, 0xAB, 0xE2, 0x78, 0x07, 0xE8, 0x73, 0xBF
};

typedef struct {
	DWORD offset;
	DWORD length;
} FILE_INFO,*PFILE_INFO;

struct HEADERPAIR{
	int offset;
	int count;
};

struct ss_header{
	DWORD szZiped;
	DWORD szOrigianl;
};

struct SCENEHEADER{
	int headerLength;
	HEADERPAIR varInfo;
	HEADERPAIR varNameIndex;
	HEADERPAIR varName;
	HEADERPAIR cmdInfo;
	HEADERPAIR cmdNameIndex;
	HEADERPAIR cmdName;
	HEADERPAIR SceneNameIndex;
	HEADERPAIR SceneName;
	HEADERPAIR SceneInfo;
	HEADERPAIR SceneData;
	int ExtraKeyUse;
	int SourceHeaderLength;
};

void deCompress(char *pdeZip,char *pZiped)
{
	ss_header *hdr=(ss_header *)pZiped;
	char *pZipedEnd=pZiped+hdr->szZiped;
	pZiped+=sizeof(ss_header);
	BYTE Flag;
//	pdeZip = new char [hdr->szOrigianl];
	do 
	{
		Flag = *pZiped++;
		for(BYTE i=0;i<8;i++)
		{
			switch (Flag&1)
			{
			case 0:
				{
					WORD ctlByte=*(PWORD)pZiped;
					WORD delta=ctlByte>>4;
					BYTE iRepeat=(ctlByte&0xF)+2;
					while (iRepeat--)
					{
						*pdeZip++=*(pdeZip-delta);
					}
				//	memcpy(pdeZip,pdeZip-delta,iRepeat);
				//	pdeZip+=iRepeat;
					pZiped+=2;
				}
				break;
			case 1:
				*pdeZip++=*pZiped++;
				break;
			}
			Flag>>=1;
		}
	} while (pZiped<=pZipedEnd);
}

///datablock:size size+data
int main(int argc, char* argv[])
{
	if(argc != 2)
		return -1;
	
	FILE *fp=fopen(argv[1],"rb");
	fseek(fp,0,SEEK_END);
	DWORD dwFileSize=ftell(fp);
	rewind(fp);
	char *pFile=new char [dwFileSize];
	fread(pFile,dwFileSize,1,fp);
	fclose(fp);
	SCENEHEADER scene;
	memcpy(&scene,pFile,sizeof(SCENEHEADER));
	PFILE_INFO pSizeTable,pNameLenTable;
	char *pDataBlock;
	LPWSTR pNameTable;
	DWORD FileCnt,i=0;
	pNameLenTable	=PFILE_INFO	(pFile+scene.SceneNameIndex.offset);
	pSizeTable		=PFILE_INFO	(pFile+scene.SceneInfo.offset);
	pNameTable		=LPWSTR		(pFile+scene.SceneName.offset);
	FileCnt			=scene.SceneInfo.count;
	pDataBlock		=pFile+scene.SceneData.offset;
	while(FileCnt--)
	{
		i=0;
		DWORD zipedSize=pSizeTable->length;
		WCHAR pwFileName[MAX_PATH];
		memset(pwFileName,0,MAX_PATH*2);
		wcsncpy(pwFileName,pNameTable+pNameLenTable->offset,pNameLenTable->length);
		wprintf(L"[%s]\tsize:%.8X\n",pwFileName,zipedSize);
		char *pBuf=(char *)pDataBlock+pSizeTable->offset;DWORD i=0;
		while (i < zipedSize) *pBuf++ ^= pck_xor_table[i++%256];
		ss_header *hdr=(ss_header *)(pDataBlock+pSizeTable->offset);
		fp=_wfopen(pwFileName,L"wb");
		char *pBuffer= NULL;
		try{
			pBuffer = new char[hdr->szOrigianl+0x256];
		}
		catch(...)
		{
			wchar_t szInfo[1024];
			wmemset(szInfo, 0, sizeof(szInfo)/sizeof(wchar_t));
			swprintf(szInfo, L"Invalid Block Size : 0x%08x\nMaybe the decompression function\n"
				             L"(or encoding table) has been modified\n",
				             hdr->szOrigianl);
			MessageBoxW(NULL, szInfo, L"SiglusUnpacker", MB_OK);
			return -1;
		}
		memset(pBuffer,0,hdr->szOrigianl + 0x256);
		deCompress(pBuffer,pDataBlock+pSizeTable->offset);
		fwrite(pBuffer,hdr->szOrigianl,1,fp);
		delete pBuffer;
		fclose(fp);
		pSizeTable++;
		pNameLenTable++;
	}
	delete []pFile;
	return 0;
}
